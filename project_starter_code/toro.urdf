Commit message: first step

File: project_starter_code/toro.urdf (robot description, URDF)
Before this commit: robot DLR_TORO, 34 links, 33 joints
Links:
- link RL_foot: mass 1.4241951000 -> 142.41951000
